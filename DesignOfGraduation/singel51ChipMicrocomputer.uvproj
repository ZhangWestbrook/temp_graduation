# Keil uVision project singel51ChipMicrocomputer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: singel51ChipMicrocomputer +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Code;.\Code
  group Source Group 1
    ./Code/: Main.c bujin.c Lcd1602.c serialPort.c
